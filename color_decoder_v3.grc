options:
  parameters:
    generate_options: qt_gui
    id: color_decoder_v2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: broj
  id: variable_qtgui_range
  parameters:
    start: '-300'
    step: '1'
    stop: '300'
    value: '0'
  states: {}
- name: color_Strength
  id: variable_qtgui_range
  parameters:
    start: '100'
    step: '1'
    stop: '3000'
    value: '500'
  states: {}
- name: filter_frequency
  id: variable_qtgui_range
  parameters:
    start: 5e5
    step: '1'
    stop: 3e6
    value: 1e6
  states: {}
- name: hue
  id: variable_qtgui_range
  parameters:
    label: hue
    start: '-3.14'
    step: '0.05'
    stop: '3.14'
    value: '0'
  states: {}
- name: line_length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '100'
    value: '0'
  states: {}
- name: rangedb
  id: variable_qtgui_range
  parameters:
    label: rangedb
    start: '0'
    step: '0.05'
    stop: '120'
    value: '20'
  states: {}
- name: rangee
  id: variable_qtgui_range
  parameters:
    label: contrast
    start: '-5'
    step: '0.01'
    stop: '5'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000000'
  states: {}
- name: threshhold
  id: variable_qtgui_range
  parameters:
    label: threshold
    start: '-300'
    step: '0.05'
    stop: '-30'
    value: '-60'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: rangee
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: rangee
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-4.433618e6'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*0.4
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: 5e6
    interp: '1'
    low_cutoff_freq: 3.5e6
    samp_rate: samp_rate*0.4
    type: interp_fir_filter_fcc
    width: 5e5
    win: window.WIN_HAMMING
  states: {}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 4.8e6
    low_cutoff_freq: 4.1e6
    samp_rate: samp_rate*0.4
    type: fir_filter_fff
    width: 2e5
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: broj
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\mirko\Downloads\test_file_output
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/orqa-internship/Downloads/pokusaj_1
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '180'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          LINE_LEN        = 1024
          LINES_PER_FIELD = 312
          ACTIVE_LINES    = 288
          ACTIVE_LEN      = 832
          ACTIVE_START    = 180
          VBI_TOP_LINES   = 20

          BROAD_MIN_WIDTH = 300
          HSYNC_MIN_WIDTH = 50
          HSYNC_MAX_WIDTH = 120

          FRAME_SIZE = 2 * ACTIVE_LINES * ACTIVE_LEN

          def __init__(self, threshold=-60.0):
              gr.basic_block.__init__(
                  self, name="pal_sync_color",
                  in_sig=[np.float32, np.complex64],  # Changed to 2 inputs (Y float, Chroma complex)
                  out_sig=[np.float32, np.float32, np.float32])
              self.threshold = float(threshold)
              self._held = None
              self._held_parity = None
              self._min_input = (self.LINES_PER_FIELD + 3) * self.LINE_LEN
              self.set_output_multiple(self.FRAME_SIZE)

          def forecast(self, noutput_items, ninput_items_required):
              n_frames = max(1, noutput_items // self.FRAME_SIZE)
              n_needed = n_frames * self._min_input
              try:
                  for i in range(2): # Changed for 2 inputs
                      ninput_items_required[i] = n_needed
                  return
              except TypeError:
                  return [n_needed, n_needed]

          def _find_pulses(self, sig):
              below = (sig < self.threshold).astype(np.int8)
              edges = np.diff(below)
              falls = np.where(edges ==  1)[0] + 1
              rises = np.where(edges == -1)[0] + 1
              if falls.size == 0 or rises.size == 0:
                  return np.empty(0, np.int32), np.empty(0, np.int32)
              rises = rises[rises > falls[0]]
              n = min(falls.size, rises.size)
              return falls[:n].astype(np.int32), (rises[:n] - falls[:n]).astype(np.int32)

          def _find_vsync_block(self, starts, widths):
              broad = np.where(widths >= self.BROAD_MIN_WIDTH)[0]
              if broad.size < 2:
                  return -1, np.empty(0, np.int32)
              i = 0
              while i < broad.size:
                  j = i
                  while (j + 1 < broad.size and
                         starts[broad[j + 1]] - starts[broad[j]] < 2 * self.LINE_LEN):
                      j += 1
                  if j > i:
                      cluster = broad[i:j+1]
                      vs_end = int(starts[broad[j]] + widths[broad[j]])
                      return vs_end, starts[cluster]
                  i = j + 1
              return -1, np.empty(0, np.int32)

          def _detect_parity(self, broad_starts, h0):
              if broad_starts.size == 0:
                  return 0
              delta = (h0 - int(broad_starts[0])) % self.LINE_LEN
              aligned = min(delta, self.LINE_LEN - delta)
              offset  = abs(delta - self.LINE_LEN // 2)
              return 0 if aligned < offset else 1

          def general_work(self, input_items, output_items):
              y, c = input_items[0], input_items[1]
              y_o, u_o, v_o = output_items[0], output_items[1], output_items[2]

              n_min = min(y.size, c.size)
              out_min = min(y_o.size, u_o.size, v_o.size)
              if n_min < self._min_input or out_min < self.FRAME_SIZE:
                  return 0

              fallback = self.LINES_PER_FIELD * self.LINE_LEN

              starts, widths = self._find_pulses(y)
              if starts.size < 5:
                  self._held = None
                  for i in range(2): self.consume(i, fallback)
                  return 0

              vs_end, broad_starts = self._find_vsync_block(starts, widths)
              if vs_end < 0:
                  self._held = None
                  for i in range(2): self.consume(i, fallback)
                  return 0

              is_hsync = ((widths >= self.HSYNC_MIN_WIDTH) &
                          (widths <= self.HSYNC_MAX_WIDTH) &
                          (starts >= vs_end + 3 * self.LINE_LEN))
              idx = np.where(is_hsync)[0]
              if idx.size == 0:
                  self._held = None
                  for i in range(2): self.consume(i, fallback)
                  return 0

              h0 = int(starts[idx[0]])
              parity = self._detect_parity(broad_starts, h0)

              first_line = h0 + (self.VBI_TOP_LINES - 1) * self.LINE_LEN
              last_line  = first_line + (self.ACTIVE_LINES - 1) * self.LINE_LEN
              end_y = last_line + self.ACTIVE_START + self.ACTIVE_LEN
              if end_y > n_min:
                  return 0

              hs_all = starts[(widths >= self.HSYNC_MIN_WIDTH) &
                              (widths <= self.HSYNC_MAX_WIDTH)]
              tol = self.LINE_LEN // 8
              line_starts = first_line + np.arange(self.ACTIVE_LINES) * self.LINE_LEN
              if hs_all.size:
                  for k in range(self.ACTIVE_LINES):
                      est = line_starts[k]
                      cand = hs_all[(hs_all >= est - tol) & (hs_all <= est + tol)]
                      if cand.size:
                          line_starts[k] = cand[np.argmin(np.abs(cand - est))]

              # --- BURST PHASE ESTIMATOR & PAL COMB FILTER ---
              # 1. Extract the Color burst for every line
              burst_idx = np.clip(line_starts[:, None] + np.arange(int(5.5 * 16), int(7.8 * 16)), 0, n_min - 1)
              bursts = np.mean(c[burst_idx], axis=1)

              # 2. Add the previous line's burst to the current line. 
              # PAL bursts swing +45 and -45 degrees. Adding them cancels the swing, revealing the absolute phase!
              bursts_prev = np.roll(bursts, 1)
              bursts_prev[0] = bursts[0] 
              
              # Calculate mathematical phase error for the line
              phase_corr = np.angle(bursts + bursts_prev) - np.pi
              
              # 3. Rotate burst to determine if this is a +V or -V line (PAL switch)
              rotated_bursts = bursts * np.exp(-1j * phase_corr)
              v_mult = np.where(np.imag(rotated_bursts) > 0, 1.0, -1.0)

              # 4. Extract active video data
              s_y = line_starts + self.ACTIVE_START
              col = np.arange(self.ACTIVE_LEN)
              idx2d = s_y[:, None] + col[None, :]

              y_f = y[idx2d]
              c_f = c[idx2d]

              # 5. Apply the perfect phase correction to the entire active line
              c_f_corrected = c_f * np.exp(-1j * phase_corr[:, None])
              
              # Split complex data cleanly into U and V
              u_f = np.real(c_f_corrected)
              v_f = np.imag(c_f_corrected) * v_mult[:, None]

              consumed = min(h0 + (self.LINES_PER_FIELD - 6) * self.LINE_LEN, n_min)

              if self._held is None:
                  self._held = (y_f, u_f, v_f)
                  self._held_parity = parity
                  for i in range(2): self.consume(i, consumed)
                  return 0

              cur = (y_f, u_f, v_f)
              if self._held_parity == 0:
                  field_a, field_b = self._held, cur
              else:
                  field_a, field_b = cur, self._held

              for fa, fb, out in zip(field_a, field_b, (y_o, u_o, v_o)):
                  frame = np.empty((2 * self.ACTIVE_LINES, self.ACTIVE_LEN), dtype=np.float32)
                  frame[0::2] = fa
                  frame[1::2] = fb
                  out[:frame.size] = frame.ravel()

              self._held = None
              self._held_parity = None
              for i in range(2): self.consume(i, consumed)
              return self.FRAME_SIZE
    threshold: threshhold
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Per-sample YUV -> packed RGB24.
      in0 Y (0..255), in1 U (~+/-0.2), in2 V (~+/-0.2)
      out: uint8, 3 bytes per Y sample (R,G,B)
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.interp_block):
          def __init__(self, u_gain=500.0, v_gain=500.0):
              gr.interp_block.__init__(
                  self, name='yuv_to_rgb',
                  in_sig=[np.float32, np.float32, np.float32],
                  out_sig=[np.uint8],
                  interp=3)
              self.u_gain = float(u_gain)
              self.v_gain = float(v_gain)
              # 832*576*3 = 1437696 output bytes per frame
              self.set_output_multiple(832 * 576 * 3)

          def work(self, input_items, output_items):
              y = input_items[0]
              u = input_items[1] * self.u_gain
              v = input_items[2] * self.v_gain
              out = output_items[0]
              n = len(y)

              r = y + 1.140 * v
              g = y - 0.395 * u - 0.581 * v
              b = y + 2.032 * u

              rgb = np.empty(n * 3, dtype=np.uint8)
              rgb[0::3] = np.clip(r, 0, 255).astype(np.uint8)
              rgb[1::3] = np.clip(g, 0, 255).astype(np.uint8)
              rgb[2::3] = np.clip(b, 0, 255).astype(np.uint8)
              out[:n * 3] = rgb
              return n * 3
    u_gain: color_Strength
    v_gain: color_Strength
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filter_frequency
    decim: '1'
    gain: '1'
    samp_rate: samp_rate*0.4
    type: fir_filter_ccf
    width: 400e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: '0.4'
    type: fff
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import time
      import threading
      import subprocess  # <--- Added this line

      def launch_ffplay():
          time.sleep(2) # let GR's TCP server come up first
          cmd = [
              "ffplay",
              "-f", "rawvideo",
              "-pixel_format", "rgb24",
              "-video_size", "832x576",
              "-framerate", "25",
              "-i", "tcp://127.0.0.1:2000",
          ]
          try:
              # Removed the Windows-only creationflags argument
              subprocess.Popen(cmd) 
          except Exception as e:
              print(f"ERROR: {e}")

      threading.Thread(target=launch_ffplay, daemon=True).start()
    section: main_after_init
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 5.917e9
    dc_offs_enb0: auto
    dev_addr: type=b200
    gain0: rangedb
    iq_imbal_enb0: auto
    samp_rate: '16000000'
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', pfb_arb_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', band_pass_filter_1, '0']
- [analog_quadrature_demod_cf_0_0, '0', band_reject_filter_0, '0']
- [analog_rail_ff_0, '0', blocks_add_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_1, '0', blocks_multiply_xx_0, '0']
- [band_reject_filter_0, '0', analog_rail_ff_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_1, '0', epy_block_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [epy_block_0, '0', epy_block_0_0, '0']
- [epy_block_0, '1', epy_block_0_0, '1']
- [epy_block_0, '2', epy_block_0_0, '2']
- [epy_block_0_0, '0', blocks_file_sink_0, '0']
- [epy_block_0_0, '0', network_tcp_sink_0, '0']
- [low_pass_filter_0, '0', virtual_sink_1, '0']
- [pfb_arb_resampler_xxx_0, '0', band_pass_filter_1, '0']
- [pfb_arb_resampler_xxx_0, '0', band_reject_filter_0, '0']
- [uhd_usrp_source_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [virtual_source_0, '0', blocks_add_const_vxx_1, '0']
- [virtual_source_1, '0', epy_block_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
